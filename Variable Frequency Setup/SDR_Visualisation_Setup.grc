options:
  parameters:
    generate_options: qt_gui
    id: First_Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Center_Frequency
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 70e6
    step: .5e6
    stop: 7e9
    value: 3e9
  states: {}
- name: Cutoff
  id: variable_qtgui_range
  parameters:
    label: Cutoff
    start: '10'
    step: '1'
    stop: 100e3
    value: 10e3
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '20'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: Low_Cut
  id: variable_qtgui_range
  parameters:
    label: Low_Cut
    start: 1e3
    step: '1'
    stop: 600e3
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/multiscale-optical-control/Documents/Optics-Table/Variable Frequency Steup/Data_Test.txt
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: Low_Cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '10'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Center_Frequency
    fftsize: '1024'
    gui_hint: (0,2)
    name: '"recieved signal"'
    type: complex
    ymin: '-90'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: Center_Frequency
    dev_addr: serial=3474452
    gain0: Gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_number_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
